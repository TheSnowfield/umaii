# Keil uVision project UmaiiDX.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F412RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware +hex
  BeforeMake: python third-party\rucfs\tools\mkfs.rucfs.py ./rootfs/ build/rucfs.img
  BeforeMake: python tools\taggen.py 0.0.1 umaiidx build/Debug/githash.h
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=3
  c define: STM32F412Rx FROST_PORTED_TIME_TICK FROST_PORTED_LOG_PRINT CFG_TUSB_MCU=OPT_MCU_STM32F4  CFG_TUSB_CONFIG_FILE=<app/usb/tusb_config.h>
  c include: src;src/app;src/app/usb;src/sys;src/sys/hardware;src/include;src/core;src/core/include;src/core/hal/include;src/core/device/f411xe;third-party;third-party/frost;third-party/rucfs/src;third-party/STM32F4xx_HAL_Driver/Inc;third-party/tinyusb;third-party/tinyusb/src;third-party/tinyusb/hw;build/Debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group MAIN
    ./src/: boot.c
  group CORE
    src/core/: system_stm32f4xx.c
    ./src/core/device/f412rx/: startup_stm32f412rx.s
    ./src/core/: stm32f4xx_it.c
  group SYS
    ./src/sys/: dfu.c fault.c debug.c
  group SYS/HARDWARE
    ./src/sys/hardware/: ch334f.c mpr121.c ws2812.c
    ./src/sys/hardware/common/: iic.c uart.c
  group APP
    src/app/: app.c
    ./src/app/input/: gamebtn.c touchpanel.c
    ./src/app/: led.c light.c
    ./src/app/misc/: frost.c logprint.c
    ./src/app/manager/: resource.c
    ./src/app/usb/: desc.c
    ./src/app/usb/device/: audio.c cdc.c
    ./src/app/board/: io4.c led15093.c
  group THIRD-PARTY/RUCFS
    ./third-party/rucfs/src/: rucfs.c
  group THIRD-PARTY/FROST
    ./third-party/frost/src/: await.c engine.c list.c tls.c
  group THIRD-PARTY/TINYUSB
    ./third-party/tinyusb/src/: tusb.c
    ./third-party/tinyusb/src/class/audio/: audio_device.c
    ./third-party/tinyusb/src/class/bth/: bth_device.c
    ./third-party/tinyusb/src/class/cdc/: cdc_device.c cdc_host.c cdc_rndis_host.c
    ./third-party/tinyusb/src/class/dfu/: dfu_device.c dfu_rt_device.c
    ./third-party/tinyusb/src/class/hid/: hid_device.c hid_host.c
    ./third-party/tinyusb/src/class/midi/: midi_device.c
    ./third-party/tinyusb/src/class/msc/: msc_device.c msc_host.c
    ./third-party/tinyusb/src/class/net/: ncm_device.c ecm_rndis_device.c
    ./third-party/tinyusb/src/class/usbtmc/: usbtmc_device.c
    ./third-party/tinyusb/src/class/vendor/: vendor_host.c vendor_device.c
    ./third-party/tinyusb/src/class/video/: video_device.c
    ./third-party/tinyusb/src/common/: tusb_fifo.c
    ./third-party/tinyusb/src/device/: usbd.c usbd_control.c
    ./third-party/tinyusb/src/host/: hub.c usbh.c
    ./third-party/tinyusb/src/typec/: usbc.c
    ./third-party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c
  group THIRD-PARTY/HAL
    ./third-party/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
